# Keil uVision project ScanKeyProject.uvprojx, settings and files
target PY32F071xB_Project (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: PY32F071xB Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00020000) IROM2(0x1FFF3100,0x00000020) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F071xB,USE_FULL_LL_DRIVER
  c include: ..\..\PY32F071_Firmware_V1.1.0\Drivers\CMSIS\Include;..\..\PY32F071_Firmware_V1.1.0\Drivers\PY32F071_HAL_Driver\Inc;..\Src\Inc;..\..\PY32F071_Firmware_V1.1.0\Drivers\CMSIS\Device\PY32F071\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x1fff3100 size 0x20
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Common
    ../Src/: system_py32f071.c startup_py32f071xx.s
  group Application/User
    ../Src/: ScanKeyApp.c main.c py32f071_it.c board.c TimerWDog.c
  group ScanKey
    ../../../../: ScanKey.c
  group Drivers/PY32F071_HAL_Driver
    ../../PY32F071_Firmware_V1.1.0/Drivers/PY32F071_HAL_Driver/Src/: py32f071_ll_utils.c
  group Doc
    ../: readme.txt
